# IAR project Project.ewp, settings and files
configuration MB851_SUN (ARM, debug)
  General.OGChipSelectEditMenu: STM32W108CC ST STM32W108CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB851_REVD; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"; PC_GUI
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB851
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample_sun.s37
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32w108xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB954_SUN (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB954_REVC; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"; PC_GUI
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB954
configuration MB950_SUN (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB950; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"; PC_GUI
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB950
configuration MB951_SUN (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB951; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"; PC_GUI
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB951
configuration MB954_PLANET (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB954_REVC; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; PLANET_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: sample_planet.s37
configuration MB950_PLANET (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB950; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; PLANET_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: sample_planet.s37
configuration MB951_PLANET (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB951; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; PLANET_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: sample_planet.s37
configuration MB851_PLANET (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB851_REVD; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; PLANET_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: sample_planet.s37
configuration MB851_PLANET_BTL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32W108CB ST STM32W108CB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB851_REVC; STM32W108CB; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; PLANET_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: sample_planet.s37
  ILINK.IlinkConfigDefines: ST_BTL=1
configuration MB851_SUN_BTL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32W108CB ST STM32W108CB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB851_REVC; STM32W108CB; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  ILINK.IlinkConfigDefines: ST_BTL=1
  group CMSIS
    ../../../../Libraries/CMSIS/Device/ST/STM32W108xx/Source/Templates/: system_stm32w108xx.c
  group EWARM
    ./: startup_stm32w108xx.s
  group Sample_Application
    ../: solar-system.c stm32W108xx_it.c transmit.c
  group Simplemac_Library
    ../../../../Libraries/SimpleMAC/Binary/: simplemac-library.a
  group StdPeriph_Driver
    ../../../../Libraries/STM32W108xx_StdPeriph_Driver/src/: stm32w108xx_adc.c stm32w108xx_clk.c stm32w108xx_exti.c stm32w108xx_flash.c stm32w108xx_gpio.c stm32w108xx_misc.c stm32w108xx_pwr.c stm32w108xx_rst.c stm32w108xx_sc.c stm32w108xx_slptim.c stm32w108xx_tim.c stm32w108xx_wdg.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/MB851/: mb851.c
    ../../../../Utilities/STM32_EVAL/MB950/: mb950.c
    ../../../../Utilities/STM32_EVAL/MB951/: mb951.c
    ../../../../Utilities/STM32_EVAL/MB954/: mb954.c
  group STM32W108xx_HAL_Driver
    ../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/: board.c context-switch.s79 hal_adc.c hal_clocks.c hal_flash.c hal_uart.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c system-timer.c
    ../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/stm32w108/: low_level_init.c
