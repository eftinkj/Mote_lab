# Keil uVision project Project.uvproj, settings and files
target MB851_MOUSE_TX (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x803FFFF) CLOCK(24000000) CPUTYPE("Cortex-M3")
  output: MB851_MOUSE_TX +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_MB851_REVD,STM32W108CC,PLATFORM_HEADER=<Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/arm.h>,CORTEXM3,CORTEXM3_STM32W108,CORTEXM3_STM32W108CC,DISABLE_WATCHDOG,MOUSE_TX
  c misc: --C99
  c include: $FILE_DIR$\;.\..\..\..\..;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader;.\..\..\..\..\Utilities\Shared;.\..\;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include;.\..\..\..\..\Libraries\SimpleMAC\Include;.\..\..\..\..\Utilities\STM32_EVAL;.\..\..\..\..\Utilities\STM32_EVAL\Common;.\..\..\..\..\Utilities\STM32_EVAL\MB851;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\compiler
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\stm32w108xx_flash.sct
  link misc: --userlibpath=..\..\..\..\Libraries\SimpleMAC\Binary simplemac-library.lib
  group CMSIS
    ./../../../../Libraries/CMSIS/Device/ST/STM32W108xx/Source/Templates/: system_stm32w108xx.c
  group MDK-ARM
    ./: startup_stm32w108xx.s retarget.c
  group Sample_Application
    ./../: stm32W108xx_it.c
    ../: mouse.c
  group Simplemac_Library
    ../../../../Libraries/SimpleMAC/Binary/: simplemac-library.lib
  group StdPeriph_Driver
    ./../../../../Libraries/STM32W108xx_StdPeriph_Driver/src/: stm32w108xx_adc.c stm32w108xx_clk.c stm32w108xx_exti.c stm32w108xx_flash.c stm32w108xx_gpio.c stm32w108xx_misc.c stm32w108xx_pwr.c stm32w108xx_rst.c stm32w108xx_sc.c stm32w108xx_slptim.c stm32w108xx_tim.c stm32w108xx_wdg.c
  group STM32_EVAL
    ./../../../../Utilities/STM32_EVAL/MB851/: mb851.c
    ./../../../../Utilities/STM32_EVAL/MB950/: mb950.c
    ./../../../../Utilities/STM32_EVAL/MB951/: mb951.c
    ./../../../../Utilities/STM32_EVAL/MB954/: mb954.c
    ../../../../Utilities/STM32_EVAL/Common/: mbxxx_i2c_lis302dl.c
  group STM32W108xx_HAL_Driver
    ./../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/: board.c hal_adc.c hal_clocks.c hal_flash.c hal_uart.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c system-timer.c
    ./../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/stm32w108/: low_level_init.c
    ../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/: context-switch.s
target MB851_MOUSE_RX (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: as above
  output: MB851_MOUSE_RX +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_MB851_REVD,STM32W108CC,PLATFORM_HEADER=<Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/arm.h>,CORTEXM3,CORTEXM3_STM32W108,CORTEXM3_STM32W108CC,DISABLE_WATCHDOG
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\stm32w108xx_flash.sct
  link misc: --userlibpath=..\..\..\..\Libraries\SimpleMAC\Binary simplemac-library.lib --autoat --pad 0xFF
target MB950_MOUSE_TX (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: IRAM(0x08040000-0x08043FFF) IROM(0x8000000-0x803FFFF) CLOCK(24000000) CPUTYPE("Cortex-M3")
  output: MB950_MOUSE_TX +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_MB950,STM32W108CC,PLATFORM_HEADER=<Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/arm.h>,CORTEXM3,CORTEXM3_STM32W108,CORTEXM3_STM32W108CC,DISABLE_WATCHDOG,MOUSE_TX
  c misc: --C99
  c include: $FILE_DIR$\;.\..\..\..\..;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader;.\..\..\..\..\Utilities\Shared;.\..\;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include;.\..\..\..\..\Libraries\SimpleMAC\Include;.\..\..\..\..\Utilities\STM32_EVAL;.\..\..\..\..\Utilities\STM32_EVAL\Common;.\..\..\..\..\Utilities\STM32_EVAL\MB950;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\compiler
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\stm32w108xx_flash.sct
  link misc: as above
target MB950_MOUSE_RX (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: as above
  output: MB950_MOUSE_RX +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_MB950,STM32W108CC,PLATFORM_HEADER=<Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/arm.h>,CORTEXM3,CORTEXM3_STM32W108,CORTEXM3_STM32W108CC,DISABLE_WATCHDOG
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\stm32w108xx_flash.sct
  link misc: as above
target MB951_MOUSE_RX (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: as above
  output: MB951_MOUSE_RX +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_MB951,STM32W108CC,PLATFORM_HEADER=<Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/arm.h>,CORTEXM3,CORTEXM3_STM32W108,CORTEXM3_STM32W108CC,DISABLE_WATCHDOG
  c misc: --C99
  c include: $FILE_DIR$\;.\..\..\..\..;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader;.\..\..\..\..\Utilities\Shared;.\..\;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include;.\..\..\..\..\Libraries\SimpleMAC\Include;.\..\..\..\..\Utilities\STM32_EVAL;.\..\..\..\..\Utilities\STM32_EVAL\Common;.\..\..\..\..\Utilities\STM32_EVAL\MB951;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\compiler
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\stm32w108xx_flash.sct
  link misc: --userlibpath=..\..\..\..\Libraries\SimpleMAC\Binary simplemac-library.Lib
target MB954_MOUSE_TX (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: as above
  output: MB954_MOUSE_TX
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_MB954_REVC,STM32W108CC,PLATFORM_HEADER=<Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/arm.h>,CORTEXM3,CORTEXM3_STM32W108,CORTEXM3_STM32W108CC,DISABLE_WATCHDOG,MOUSE_TX
  c misc: --C99
  c include: $FILE_DIR$\;.\..\..\..\..;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader;.\..\..\..\..\Utilities\Shared;.\..\;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include;.\..\..\..\..\Libraries\SimpleMAC\Include;.\..\..\..\..\Utilities\STM32_EVAL;.\..\..\..\..\Utilities\STM32_EVAL\Common;.\..\..\..\..\Utilities\STM32_EVAL\MB954;.\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\compiler
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\stm32w108xx_flash.sct
  link misc: as above
target MB954_MOUSE_RX (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: as above
  output: MB954_MOUSE_RX +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_MB954_REVC, STM32W108CC, PLATFORM_HEADER=<Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/arm.h>,CORTEXM3,CORTEXM3_STM32W108,CORTEXM3_STM32W108CC, DISABLE_WATCHDOG, __SOURCEFILE__=<$FILE_FNAME$>
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\stm32w108xx_flash.sct
  link misc: as above
