# IAR project Project.ewp, settings and files
configuration MB851_MOUSE_TX (ARM, debug)
  General.OGChipSelectEditMenu: STM32W108CC ST STM32W108CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB851_REVD; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; MOUSE_TX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB851
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mouse_tx.s37
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32w108xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB851_MOUSE_RX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB851_REVD; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG
  OBJCOPY.OOCOutputFile: mouse_rx.s37
configuration MB950_MOUSE_TX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB950; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; MOUSE_TX
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB950
configuration MB950_MOUSE_RX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB950; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: mouse_rx.s37
configuration MB954_MOUSE_TX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB954_REVC; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; MOUSE_TX
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB954
configuration MB954_MOUSE_RX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB954_REVC; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: mouse_rx.s37
configuration MB951_MOUSE_RX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB951; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB951
  OBJCOPY.OOCOutputFile: mouse_rx.s37
  group CMSIS
    ../../../../Libraries/CMSIS/Device/ST/STM32W108xx/Source/Templates/: system_stm32w108xx.c
  group EWARM
    ./: startup_stm32w108xx.s
  group Mouse_Application
    ../: mouse.c stm32W108xx_it.c
  group Simplemac_Library
    ../../../../Libraries/SimpleMAC/Binary/: simplemac-library.a
  group StdPeriph_Driver
    ../../../../Libraries/STM32W108xx_StdPeriph_Driver/src/: stm32w108xx_adc.c stm32w108xx_clk.c stm32w108xx_exti.c stm32w108xx_flash.c stm32w108xx_gpio.c stm32w108xx_misc.c stm32w108xx_pwr.c stm32w108xx_rst.c stm32w108xx_sc.c stm32w108xx_slptim.c stm32w108xx_tim.c stm32w108xx_wdg.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/MB851/: mb851.c
    ../../../../Utilities/STM32_EVAL/MB950/: mb950.c
    ../../../../Utilities/STM32_EVAL/MB951/: mb951.c
    ../../../../Utilities/STM32_EVAL/MB954/: mb954.c
    ../../../../Utilities/STM32_EVAL/Common/: mbxxx_i2c_lis302dl.c
  group STM32W108xx_HAL_Driver
    ../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/: board.c context-switch.s79 hal_adc.c hal_clocks.c hal_flash.c hal_uart.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c system-timer.c
    ../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/stm32w108/: low_level_init.c
