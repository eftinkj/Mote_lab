<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MB851_TALK</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MB950_TALK</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MB951_TALK</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MB954_TALK</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MB_SnT_X2_Mote</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Source\Templates\system_stm32w108xx.c</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\startup_stm32w108xx.s</name>
    </file>
  </group>
  <group>
    <name>Mote_Apps</name>
    <group>
      <name>APP_TEMP_1WIRE</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\APP_TEMP_1WIRE\app_temp_1wire_main.c</name>
      </file>
    </group>
    <group>
      <name>PRJ_NET_ONLY</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\PRJ_NET_ONLY\config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\PRJ_NET_ONLY\network_only_include_c.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\mote.c</name>
    </file>
  </group>
  <group>
    <name>Mote_Libs</name>
    <group>
      <name>defs</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\defs\esnl_pub.h</name>
      </file>
    </group>
    <group>
      <name>doc</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\doc\New_config_format.odt</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\doc\templet_file.c</name>
      </file>
    </group>
    <group>
      <name>FEAT_adpcm</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\decode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\encode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\g711.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\g711.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\g721.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\g723_16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\g723_24.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\g723_40.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\g72x.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_adpcm\g72x.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_BaseStation</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_BaseStation\bs_base.c</name>
      </file>
    </group>
    <group>
      <name>FEAT_CogNet</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_CogNet\microstrain.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_CogNet\microstrain.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_CogNet\rssi_sensor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_CogNet\rssi_sensor.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_CogNet\rtls_beacon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_CogNet\rtls_beacon.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_CogNet\rtls_calculate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_CogNet\rtls_calculate.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_HIO</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_HIO\hio_xbee.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_HIO\hio_xbee_prv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_HIO\hio_xbee_pub.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_LCD</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_LCD\lcd_char2x8.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_LCD\lcd_char2x8.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_Networking</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\ChannelSwitching.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\ChannelSwitching.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\CongestionControl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\CongestionControl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\Phy_layer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\Phy_layer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\tsp_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\tsp_common_prv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Networking\tsp_common_pub.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_Queuing</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Queuing\Q_Droptail.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Queuing\Q_Droptail.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Queuing\Q_SFQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Queuing\Q_SFQ.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Queuing\Queuing.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Queuing\Queuing.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_Routing</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\mpr_selector_table.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\mpr_selector_table.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\packet_AODV.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing_AODV.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing_AODV.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing_MMCR.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing_MMCR.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing_MMCR_MPR_select.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing_MMCR_MPR_select.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing_OEDSR.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Routing\routing_OEDSR.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_Scheduler</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Scheduler\sch_basic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Scheduler\sch_basic_prv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Scheduler\sch_basic_pub.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Scheduler\timer.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_Scheduler\timer.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_SigProc</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\sig_basic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\sig_basic_prv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\sig_basic_pub.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\src_8bit_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\src_8bit_adc_prv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\src_8bit_adc_pub.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\src_dummy.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\src_dummy_prv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\src_dummy_pub.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\ssn_8bit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\ssn_8bit_prv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\ssn_8bit_pub.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\ssn_basic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\ssn_basic_prv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_SigProc\ssn_basic_pub.h</name>
      </file>
    </group>
    <group>
      <name>FEAT_STM32W</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_STM32W\STM32W_Radio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\FEAT_STM32W\STM32W_Radio.h</name>
      </file>
    </group>
    <group>
      <name>HW_LIB</name>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\HW_LIB\arm_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\HW_LIB\arm_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\HW_LIB\OneWire.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\HW_LIB\OneWire.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\HW_LIB\RTC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arm_mote\HW_LIB\RTC.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\Application.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\Application.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\common_constants.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\feat_enable.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\hw_specific.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\network_hardware.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\network_hardware_ADFS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\network_hardware_LGS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\packet.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\packet.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\sys_func.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\arm_mote\sys_func.h</name>
    </file>
  </group>
  <group>
    <name>Simplemac_Library</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\SimpleMAC\Binary\simplemac-library.a</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_sc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_slptim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\src\stm32w108xx_wdg.c</name>
    </file>
  </group>
  <group>
    <name>STM32_EVAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32_EVAL\MB851\mb851.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32_EVAL\MB950\mb950.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32_EVAL\MB951\mb951.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32_EVAL\MB954\mb954.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32_EVAL\MB_SnT_X2\mb_snt_x2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32_EVAL\MB_SnT_X2\mb_snt_x2.h</name>
    </file>
  </group>
  <group>
    <name>STM32W108xx_HAL_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\context-switch.s79</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\hal_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\hal_clocks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\hal_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\hal_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108\low_level_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\mfg-token.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\micro-common-internal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\micro-common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\micro.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\nvm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\sleep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\system-timer.c</name>
    </file>
  </group>
  <group>
    <name>Talk_Application</name>
    <file>
      <name>$PROJ_DIR$\..\solar-system.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32w108xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32W108xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32W108xx_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\transmit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\transmit.h</name>
    </file>
  </group>
</project>


